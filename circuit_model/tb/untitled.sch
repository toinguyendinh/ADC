v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/userdata/k63D/toind_63d/Desktop/project/circuit_model/lib/cc_inv.sym} 410 -320 0 0 {name=Xi_1 L12=0.15 Wp12=1.2 Wn12=0.65 L34=0.15 Wp34=1.2 Wn34=0.65}
